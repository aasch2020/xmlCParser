## Kconfig
```kconfig
# thing
config SECURITY_MYSEC
	bool "mysec support"
	depends on SECURITY
	default n
	help
	  puts in mysec
```
